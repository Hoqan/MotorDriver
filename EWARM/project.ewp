# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F470xK GD GD32F470xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F470
  ICCARM.CCIncludePath2: ..\src\bsp\mcu\gd32; ..\src\bsp\mcu\gd32\CMSIS; ..\src\bsp\mcu\gd32\CMSIS\GD\GD32F4xx\Include; ..\src\bsp\mcu\gd32\GD32F4xx_standard_peripheral\Include; ..\src\bsp\hal; ..\src\bsp\drivers; ..\src\comm\canopen; ..\src\control; ..\src\utils\container; ..\src\utils\math; ..\src\utils\timers; ..\src\utils\RTT; ..\src\app; ..\src\bsp; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group app
    ../src/app/: app_servo_motor.cpp app_servo_motor.h main.cpp
  group bsp
    ../src/bsp/: basetype.h board_cfg.h
  group bsp/drivers
    ../src/bsp/drivers/: as5600.cpp as5600.h ma702.cpp ma702.h oledfont.h ssd1306.cpp ssd1306.h
  group bsp/hal
    ../src/bsp/hal/: iic.h iic.tpp iostream.h pinctrl.cpp pinctrl.h pwm.cpp pwm.h spi.cpp spi.h uart.cpp uart.h
  group bsp/mcu/gd32/CMSIS
    ../src/bsp/mcu/gd32/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group bsp/mcu/gd32/gd32f4xx_peripheral
    ../src/bsp/mcu/gd32/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group bsp/mcu/gd32/startup
    ../src/bsp/mcu/gd32/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450_470.s
  group comm/canopen
    ../src/comm/canopen/: object.h pdo.h sdo.h
  group control
    ../src/control/: current_loop.cpp current_loop.h velocity_loop.cpp velocity_loop.h
  group test
    ../src/test/: test_ssd1306.cpp test_systimer.cpp
  group utils
    ../src/utils/: common_utils.h
  group utils/math
    ../src/utils/math/: filter.cpp filter.h math_common.h order1_lpf.cpp order1_lpf.h order2_lpf.cpp order2_lpf.h pid.cpp pid.h
  group utils/RTT
    ../src/utils/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group utils/timers
    ../src/utils/timers/: stop_watch.cpp stop_watch.h sys_timer.h sys_timer.tpp
